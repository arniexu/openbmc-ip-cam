# Trim KVM and virtual media functions.
PACKAGECONFIG:remove = "kvm vm-websocket"
