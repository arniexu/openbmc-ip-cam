# Trim x86 CPU diagnosis related functions.
PACKAGECONFIG:remove = "cpuinfo cpuinfo-peci"
