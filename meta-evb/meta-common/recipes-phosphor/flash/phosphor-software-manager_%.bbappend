# Trim BIOS related software update functions.
PACKAGECONFIG:remove = "flash_bios bios-software-update cpld-software-update i2cvr-software-update"
